EXTRA_OECONF += " --disable-info "
